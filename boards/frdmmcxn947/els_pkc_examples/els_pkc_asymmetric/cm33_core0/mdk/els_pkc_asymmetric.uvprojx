# Keil uVision project els_pkc_asymmetric.uvprojx, settings and files
target els_pkc_asymmetric debug (ARM-ADS)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: els_pkc_asymmetric.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MCXN947VDF_cm33_core0, MCUXPRESSO_SDK
  c misc: -Wno-tautological-constant-compare  -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x68000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x10100000 size 0x100000
  scatter file: MCXN947_cm33_core0_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-D__stack_size__=0x1000"
  group main
    ../: els_pkc_asymmetric.c els_pkc_asymmetric.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.md
target els_pkc_asymmetric release (ARM-ADS)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: els_pkc_asymmetric.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MCXN947VDF_cm33_core0, MCUXPRESSO_SDK
  c misc: as above
  c include: ..
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x68000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x10100000 size 0x100000
  scatter file: MCXN947_cm33_core0_flash.scf
  link misc: as above
software components: MCXN947 els_pkc:els_pkc_platform 1.9.0, MCXN947 els_pkc:els_pkc_main 1.9.0, Device:SDK Drivers:common 2.4.1, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:power 2.3.0, Device:SDK Drivers:reset 2.1.2, Device:CMSIS:MCXN947_header 1.0.0, Device:Startup 1.1.0, Device:SDK Drivers:lpuart 2.3.2, Device:SDK Drivers:gpio 2.7.3, Device:SDK Drivers:port 2.5.0, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.1, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:SDK Utilities:serial_manager 1.0.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Utilities:misc_utilities 1.1.1, MCXN947 els_pkc:els_pkc_random_modes_ctr 1.9.0, MCXN947 els_pkc:els_pkc_trng_type_els 1.9.0, MCXN947 els_pkc:els_pkc_flow_protection 1.9.0, MCXN947 els_pkc:els_pkc_secure_counter 1.9.0, MCXN947 els_pkc:els_pkc_pre_processor 1.9.0, MCXN947 els_pkc:els_pkc_memory 1.9.0, MCXN947 els_pkc:els_pkc_aes 1.9.0, MCXN947 els_pkc:els_pkc_trng 1.9.0, MCXN947 els_pkc:els_pkc_core 1.9.0, MCXN947 els_pkc:els_pkc_param_integrity 1.9.0, MCXN947 els_pkc:els_pkc_toolchain 1.9.0, MCXN947 els_pkc:els_pkc_key 1.9.0, MCXN947 els_pkc:els_pkc_els 1.9.0, MCXN947 els_pkc:els_pkc_session 1.9.0, MCXN947 els_pkc:els_pkc_ecc 1.9.0, MCXN947 els_pkc:els_pkc_buffer 1.9.0, MCXN947 els_pkc:els_pkc_els_header_only 1.9.0, MCXN947 els_pkc:els_pkc_els_common 1.9.0, MCXN947 els_pkc:els_pkc_hash 1.9.0, MCXN947 els_pkc:els_pkc_mac_modes 1.9.0, MCXN947 els_pkc:els_pkc_aead_modes 1.9.0, MCXN947 els_pkc:els_pkc_data_integrity 1.9.0, MCXN947 els_pkc:els_pkc_cipher_modes 1.9.0, MCXN947 els_pkc:els_pkc_hashmodes 1.9.0, MCXN947 els_pkc:els_pkc_mac 1.9.0, MCXN947 els_pkc:els_pkc_padding 1.9.0, MCXN947 els_pkc:els_pkc_hmac 1.9.0, MCXN947 els_pkc:els_pkc_aead 1.9.0, MCXN947 els_pkc:els_pkc_cipher 1.9.0, MCXN947 els_pkc:els_pkc_random 1.9.0, MCXN947 els_pkc:els_pkc_random_modes 1.9.0, MCXN947 els_pkc:els_pkc_prng 1.9.0, MCXN947 els_pkc:els_pkc_math 1.9.0, MCXN947 els_pkc:els_pkc_rsa 1.9.0, MCXN947 els_pkc:els_pkc_pkc 1.9.0, MCXN947 els_pkc:doc:doc_mcxn 1.9.0, MCXN947 els_pkc:static_lib_mcxn:mcxn 1.9.0, MCXN947 els_pkc:els_pkc_examples_aead 1.9.0, MCXN947 els_pkc:els_pkc_examples_cipher 1.9.0, MCXN947 els_pkc:els_pkc_examples_ecc 1.9.0, MCXN947 els_pkc:els_pkc_examples_els 1.9.0, MCXN947 els_pkc:els_pkc_examples_hash_modes 1.9.0, MCXN947 els_pkc:els_pkc_examples_hmac 1.9.0, MCXN947 els_pkc:els_pkc_examples_key 1.9.0, MCXN947 els_pkc:els_pkc_examples_mac_modes 1.9.0, MCXN947 els_pkc:els_pkc_examples_rsa 1.9.0, MCXN947 els_pkc:els_pkc_examples_flow_protection 1.9.0, MCXN947 els_pkc:els_pkc_examples_memory 1.9.0, MCXN947 els_pkc:els_pkc_examples_random_modes 1.9.0, Device:SDK Drivers:mcx_spc 2.4.2, CMSIS:CORE 5.9.0, Device:CMSIS:MCXN947_system 1.0.0, Device:SDK Drivers:lpflexcomm 2.2.1, Device:SDK Utilities:str 1.0.0
