# IAR project enet_txrx_ptp1588_transfer.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXN947_core0 NXP MCXN947_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MCXN947VDF_cm33_core0; ENET_PTP1588FEATURE_REQUIRED; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe188,Pe069
  ICCARM.CCIncludePath2: ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: enet_txrx_ptp1588_transfer.out
  ILINK.IlinkConfigDefines: __stack_size__=0x3000; __heap_size__=0x3000; __ram_vector_table__=1
  ILINK.IlinkIcfFile: MCXN947_cm33_core0_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCXN947VDF_cm33_core0; ENET_PTP1588FEATURE_REQUIRED; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: enet_txrx_ptp1588_transfer.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.md
