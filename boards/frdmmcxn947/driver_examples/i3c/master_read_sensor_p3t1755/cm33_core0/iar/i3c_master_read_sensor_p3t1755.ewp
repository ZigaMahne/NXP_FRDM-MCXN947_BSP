# IAR project i3c_master_read_sensor_p3t1755.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXN947_core0 NXP MCXN947_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MCXN947VDF_cm33_core0; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe188,Pe069
  ICCARM.CCIncludePath2: ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: i3c_master_read_sensor_p3t1755.out
  ILINK.IlinkIcfFile: MCXN947_cm33_core0_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCXN947VDF_cm33_core0; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: i3c_master_read_sensor_p3t1755.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.md
