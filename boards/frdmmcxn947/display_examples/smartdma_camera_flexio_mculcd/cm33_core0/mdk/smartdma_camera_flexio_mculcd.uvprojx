# Keil uVision project smartdma_camera_flexio_mculcd.uvprojx, settings and files
target smartdma_camera_flexio_mculcd debug (ARM-ADS)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: smartdma_camera_flexio_mculcd.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MCXN947VDF_cm33_core0, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x68000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x10100000 size 0x100000
  scatter file: MCXN947_cm33_core0_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
  group source
    ../: smartdma_camera_flexio_mculcd.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.md
target smartdma_camera_flexio_mculcd release (ARM-ADS)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: smartdma_camera_flexio_mculcd.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MCXN947VDF_cm33_core0, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x68000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x10100000 size 0x100000
  scatter file: MCXN947_cm33_core0_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
software components: Device:SDK Drivers:inputmux 2.0.7, Device:SDK Drivers:inputmux_connections 2.0.1, Device:SDK Drivers:flexio 2.2.2, Device:SDK Drivers:flexio_mculcd 2.1.0, Device:SDK Drivers:lpc_smartdma 2.10.0, Device:SDK Drivers:lpi2c 2.2.4, Device:SDK Drivers:st7796s 1.0.0, Device:SDK Drivers:camera-device-ov7670 1.0.2, Device:SDK Drivers:video-common 1.1.0, Device:SDK Drivers:camera-common 1.0.0, Device:SDK Drivers:camera-device-common 1.0.0, Device:SDK Drivers:camera-device-sccb 1.0.1, Device:SDK Utilities:debug_console_lite 1.0.0, Device:SDK Utilities:assert_lite 1.0.0, Device:SDK Drivers:common 2.4.1, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:reset 2.1.2, Device:CMSIS:MCXN947_header 1.0.0, Device:Startup 1.1.0, Device:SDK Drivers:lpuart 2.3.2, Device:SDK Drivers:gpio 2.7.3, Device:SDK Drivers:port 2.5.0, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:SDK Utilities:serial_manager 1.0.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Utilities:misc_utilities 1.1.1, Device:SDK Drivers:lpflexcomm 2.2.1, Device:SDK Drivers:dbi 1.0.0, Device:SDK Utilities:str 1.0.0, Device:SDK Drivers:mcx_spc 2.4.2, CMSIS:CORE 5.9.0, Device:CMSIS:MCXN947_system 1.0.0
